# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\iic;..\HARDWARE\mpu6050;..\HARDWARE\dmp;..\HARDWARE\usart;..\HARDWARE\usart;..\HARDWARE\trans
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USR
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/iic/: iic.c
    ../HARDWARE/mpu6050/: mpu6050.c
    ../HARDWARE/dmp/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/usart/: usart2.c usart2.h
    ../HARDWARE/trans/: ctd_trans.c
software components: Device:Startup 1.0.0
